# Keil uVision project demo.uvprojx, settings and files
target demo (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: fsmc
  c flags: Optim=1
  c misc: --c99
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group startup
    ./: startup_stm32f10x_hd.s
  group driver
    ./driver/: nvic.c rcc.c fsmc.c fpga.c usart.c adc.c dac.c key.c systick.c
  group main
    ./main/: main.c
  group terminal
    ./function/: terminal.c
