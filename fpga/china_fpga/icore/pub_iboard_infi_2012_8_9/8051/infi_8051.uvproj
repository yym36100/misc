# Keil uVision project infi_8051.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8052AH Intel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(12000000)
  output: infi_8051 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51
  group main
    ./main/: main.c
  group driver
    ./driver/: ds1302.c i2c.c key.c lm75.c
