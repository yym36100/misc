# Keil uVision project infinity.uvprojx, settings and files
target iBoard_infinity (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: iBoard_infinity +hex
  AfterMake: .\tools\revman.exe
  c flags: Optim=1
  c misc: --C99
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Source Group 1
    ./: STM32F10x.s
  group Driver
    ./driver/: adc.c dac.c evtft.c flash.c fpga.c fsmc.c nvic.c pwm.c rcc.c spi.c systick.c usart.c
  group Gui
    ./GUI/: button.c gui_core.c tab.c
  group Font
    ./Font/: borlandTE.c courier.c fixedsys.c font.c monaco.c nix.c simhei24.c simsun12.c simsun16.c simsun16f.c tahoma8.c tahoma9.c tahoma10.c tahoma11.c tahoma12.c tahoma26.c swave.c
  group DSO
    ./DSO/: dso.c dso_frame.c dso_menu.c dso_set.c
  group USB
    ./usb_driver/: usb.c usb_command.c usb_desc.c usb_istr.c usb_prop.c usb_pwr.c
  group RC
    ./Resource/: rc_borlandTE.c rc_courier.c rc_fixedsys.c rc_monaco.c rc_nix.c
  group MAIN
    ./main/: main.c poweron.c test.c
  group usb_ip
    ./usb_ip/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c
  group ARB
    ./ARB/: amplitude.c diagram.c frequency.c function.c infomation.c offset.c system.c title.c waveform.c arb.c burst.c frame.c
  group Meter
    ./meter/: meter.c
  group Clock
    ./Clock/: clock.c
  group log
    ./log/: log.txt
