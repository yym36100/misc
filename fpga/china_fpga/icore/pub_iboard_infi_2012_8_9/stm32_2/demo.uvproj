# Keil uVision project demo.uvproj, settings and files
target iBoard_demo (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: iBoard_demo
  AfterMake: E:\WORK\iBoard\Function\DSO\STM32\tools\revman.exe
  c flags: Optim=1
  c misc: --C99
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Source Group 1
    ./: STM32F10x.s
  group Driver
    ./driver/: adc.c dac.c evtft.c flash.c fpga.c fsmc.c nvic.c pwm.c rcc.c spi.c systick.c usart.c
  group Gui
    ./GUI/: button.c gui_core.c tab.c
  group Font
    ./Font/: borlandTE.c courier.c fixedsys.c font.c monaco.c nix.c simhei24.c simsun12.c simsun16.c simsun16f.c tahoma8.c tahoma9.c tahoma10.c tahoma11.c tahoma12.c tahoma26.c swave.c
  group DSO
    ./DSO/: dso.c dso_frame.c dso_menu.c dso_set.c
  group USB
    ./usb_driver/: usb.c usb_command.c usb_desc.c usb_istr.c usb_prop.c usb_pwr.c
  group RC
    ./Resource/: rc_borlandTE.c rc_courier.c rc_fixedsys.c rc_monaco.c rc_nix.c
  group MAIN
    ./main/: main.c poweron.c
  group usb_ip
    ./usb_ip/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c
  group ARB
    ./ARB/: amplitude.c diagram.c frame.c frequency.c function.c infomation.c offset.c system.c title.c waveform.c arb.c
  group Meter
    ./meter/: meter.c
  group Clock
    ./Clock/: clock.c
